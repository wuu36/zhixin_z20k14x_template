# IAR project hello_world.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Z20K148M ZhiXin Z20K148M
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEV_Z20K148M
  ICCARM.CCIncludePath2: D:\03_repo\zhixin_z20k14x\StdDriver\Inc; D:\03_repo\zhixin_z20k14x\Platform\Devices; D:\03_repo\zhixin_z20k14x\Platform\Devices\Z20K148M\Inc; D:\03_repo\zhixin_z20k14x\Platform; D:\03_repo\zhixin_z20k14x\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hello_world.hex
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ZhiXin\Z20K148M_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group drivers/inc
    StdDriver/Inc/: adc_drv.h aes_drv.h can_drv.h clock_drv.h cmp_drv.h cmu_drv.h common_drv.h crc_drv.h dma_drv.h eiru_drv.h ewdt_drv.h flash_drv.h gpio_drv.h i2c_drv.h i2s_drv.h int_drv.h mcpwm_drv.h pmu_drv.h regfile_drv.h rtc_drv.h scm_drv.h seru_drv.h smpu_drv.h spi_drv.h srmc_drv.h stim_drv.h sysctrl_drv.h tdg_drv.h tim_drv.h tmu_drv.h trng_drv.h uart_drv.h wdog_drv.h
  group drivers/src
    StdDriver/Src/: adc_drv.c aes_drv.c can_drv.c clock_drv.c cmp_drv.c cmu_drv.c common_drv.c crc_drv.c dma_drv.c eiru_drv.c ewdt_drv.c flash_drv.c gpio_drv.c i2c_drv.c i2s_drv.c int_drv.c mcpwm_drv.c pmu_drv.c regfile_drv.c rtc_drv.c scm_drv.c seru_drv.c smpu_drv.c spi_drv.c srmc_drv.c stim_drv.c sysctrl_drv.c tdg_drv.c tim_drv.c tmu_drv.c trng_drv.c uart_drv.c wdog_drv.c
  group example
    src/: clock_config.c clock_config.h main.c serial.c serial.h
  group platform/inc
    Platform/Devices/: device_regs.h
    Platform/: platform_cfg.h
    Platform/Devices/Z20K148M/Inc/: Z20K148M.h
  group platform/startup
    Platform/Devices/Z20K148M/Startup/IAR/: Z20K148M_startup.s
